VERSION "1.0"

NS_ :
    NS_DESC_
    CM_
    BA_DEF_
    BA_
    VAL_
    CAT_
    CLASS_

BS_:
    BU_: ECU1

BO_ 18FDD002 SpeedAndFertilizerSetting: 8 ECU1
 SG_ code : 0|8@1+ (1,0) [0xE2|0xE2] "hex" ECU1
 SG_ Speed_Cmd : 8|2@1+ (1,0) [0|3] "00=GPS测速, 01=地轮测速, 10=手动输入速度" ECU1
 SG_ Speed_Value : 10|13@1+ (0.01,0) [0|81.92] "km/h" ECU1
 SG_ fertilizer_Value : 23|15@1+ (0.001,0) [0|32.768] "kg" ECU1
